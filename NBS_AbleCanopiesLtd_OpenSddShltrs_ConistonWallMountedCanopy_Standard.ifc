Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-04-30T15:38:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Apr 30 15:38:53 2020* Host: NCL-PI02* Database: C:\Users\connm\AppData\Local\Temp\{52E351E3-A333-4526-9813-34EE75E82F66}\ifc* Database version: 5507* Database creation date: Thu Apr 30 15:38:53 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Apr 30 15:38:53 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Apr 30 15:38:53 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: ConistonWallMountedCanopy_Standard, NBS_AbleCanopiesLtd_OpenSddShltrs_ConistonWallMountedCanopy_Standard:ConistonWallMountedCanopy_Standard:191491
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: Pr_20_65_78_58 (Uniclass2015); Material: NBS_Plastic_Clear, NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_AbleCanopiesLtd_OpenSddShltrs_ConistonWallMountedCanopy_Standard; ManufacturerName: Able Canopies Ltd; ManufacturerURL: www.ablecanopies.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/feomidmi; NBSDescription: Open sided shelters; NBSReference: 45-05-75/315; ProductInformation: www.ablecanopies.co.uk/canopies/wall-mounted-canopies/coniston.html; Revision: n/a; Uniclass2015Title: Open sided shelters; Uniclass2015Code: Pr_20_65_78_58; Uniclass2015Version: Products v1.17; Version: 1
Type - NBS_Data - FrameMaterial: Aluminium box section; FrameFinish: Powder Coated; FrameColour: White as standard - Other colours available at an additional cost; RoofCovering: 35mm structured polycarbonate; OpeningsDoors: n/a; OpeningsWindows: n/a; OpeningsRoofVents: n/a; IntegralServices: n/a; RainwaterDrainage: Integeral aluminium guttering and Upvc downpipes included as standard; Accessories: The Victorian Upgrade (Victorian style post coverings), Post Pads, Signage, Side fills, Safety barrier, Rainbow package, Roller shutters, Seating; ProjectionWidth: 6 m; WallPlates: Extruded aluminium profile - fixing to the wall or steel bracket; RoofSystem: Gasketed 35 mm roof system constructed from T6 grade aluminium frame; PostsSize: 80 x 80 x 4 mm; PostsMaterial: Aluminium; WeatherResistance: Polycarbonate panels - layer of UV absorder on bothsides; FirePerformance: Polycarbonate roof panels have been tested to and meet BS476 part 7 with a class 1 fire rating
Type - Pset_FurnitureTypeCommon - Description: Wall mounted canopy; MainColor: n/a; Style: Canopy
Type - IFC - IfcExportAs: IfcBuildingElementProxyType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Generic Models; CodePerformance: n/a; Color: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: 25 years; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: sales@ablecanopies.co.uk; Material: Aluminium & 35mm structured polycarbonate with UV protection; ModelNumber: n/a; ModelReference: Coniston Wall Mounted Canopy_Standard; Name: OpenSidedShelters_ConistonWallMountedCanopy_Standard_AbleCanopiesLtd; NominalWidth: 0 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: 10 years; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
